#include "St77922Qspi.h"

#include <driver/spi_master.h>
#include <esp_heap_caps.h>
#include <esp_lcd_io_spi.h>
#include <esp_lcd_panel_io.h>
#include <freertos/semphr.h>

// LCDwiki ES3C35P pin assignment
static constexpr int PIN_CS = 10;
static constexpr int PIN_SCLK = 12;
static constexpr int PIN_D0 = 11;
static constexpr int PIN_D1 = 13;
static constexpr int PIN_D2 = 14;
static constexpr int PIN_D3 = 9;
static constexpr int PIN_BACKLIGHT = 41;   // high = on; panel reset is tied to EN

static constexpr int kChunkRows = 40;      // rows per DMA transfer
static constexpr size_t kChunkBytes = St77922Qspi::kWidth * kChunkRows * 2;

static constexpr uint32_t OPCODE_WRITE_CMD = 0x02;
static constexpr uint32_t OPCODE_WRITE_COLOR = 0x32;

static esp_lcd_panel_io_handle_t s_io = nullptr;
static SemaphoreHandle_t s_done = nullptr;
static uint16_t* s_dma[2] = {nullptr, nullptr};

struct InitCmd {
  uint8_t cmd;
  uint8_t len;
  uint16_t delayMs;
  uint8_t data[16];
};

// Extracted from the vendor demo (table at file offset 0x1CA00 of lv_demo_widgets.bin);
// zero-initialised parameters there live in .bss and are 0x00.
static const InitCmd kInit[] = {
    {0xF1, 1, 0, {0x00}},
    {0x60, 3, 0, {0x00, 0x00, 0x00}},
    {0x65, 1, 0, {0x80}},
    {0x79, 1, 0, {0x06}},
    {0x7B, 3, 0, {0x00, 0x08, 0x08}},
    {0x80, 11, 0, {0x55, 0x62, 0x2F, 0x17, 0xF0, 0x52, 0x70, 0xD2, 0x52, 0x62, 0xEA}},
    {0x81, 4, 0, {0x26, 0x52, 0x72, 0x27}},
    {0x84, 2, 0, {0x92, 0x25}},
    {0x87, 6, 0, {0x10, 0x10, 0x58, 0x00, 0x02, 0x3A}},
    {0x88, 15, 0, {0x00, 0x00, 0x2C, 0x10, 0x04, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x06}},
    {0x89, 3, 0, {0x00, 0x00, 0x00}},
    {0x8A, 11, 0, {0x13, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x10, 0x10, 0x00, 0x3E, 0x19}},
    {0x8B, 9, 0, {0x15, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x97, 0x8E}},
    {0x8C, 13, 0, {0x1D, 0xB1, 0xB1, 0x44, 0x96, 0x2C, 0x10, 0x50, 0x0F, 0x01, 0xC5, 0x12, 0x09}},
    {0x8D, 1, 0, {0x0C}},
    {0x8E, 6, 0, {0x33, 0x01, 0x0C, 0x13, 0x01, 0x01}},
    {0xB3, 2, 0, {0x00, 0x30}},
    {0xF1, 1, 0, {0x00}},
    {0x71, 1, 0, {0xC0}},
    {0x66, 2, 0, {0x02, 0x3F}},
    {0xBE, 3, 0, {0x24, 0x00, 0x9D}},
    {0x70, 12, 0, {0x01, 0xA0, 0x11, 0x40, 0xE0, 0x00, 0x11, 0x69, 0x11, 0x00, 0x00, 0x1A}},
    {0x90, 9, 0, {0x04, 0x04, 0x55, 0x74, 0x00, 0x40, 0x43, 0x27, 0x27}},
    {0x91, 9, 0, {0x04, 0x04, 0x55, 0x75, 0x00, 0x40, 0x42, 0x27, 0x27}},
    {0x92, 10, 0, {0x04, 0x44, 0x55, 0xC0, 0x06, 0x00, 0x07, 0x05, 0x90, 0x27}},
    {0x93, 10, 0, {0x04, 0x43, 0x11, 0x00, 0x00, 0x00, 0x00, 0x05, 0x90, 0x27}},
    {0x94, 6, 0, {0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {0x95, 5, 0, {0x96, 0x16, 0x00, 0x00, 0xFF}},
    {0x96, 12, 0, {0x44, 0x53, 0x03, 0x12, 0x23, 0x24, 0x06, 0x05, 0x94, 0x27, 0x00, 0x44}},
    {0x97, 12, 0, {0x44, 0x53, 0x47, 0x56, 0x20, 0x20, 0x02, 0x01, 0x94, 0x27, 0x00, 0x44}},
    {0xBA, 5, 0, {0x55, 0x94, 0x2D, 0x94, 0x27}},
    {0x9A, 7, 0, {0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00}},
    {0x9B, 7, 0, {0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00}},
    {0x9C, 13, 0, {0x5C, 0x12, 0x00, 0x00, 0x10, 0x12, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00}},
    {0x9D, 8, 0, {0x8A, 0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01}},
    {0x9E, 7, 0, {0x51, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01}},
    {0xB4, 12, 0, {0x1D, 0x1C, 0x1E, 0x0B, 0x14, 0x02, 0x13, 0x09, 0x1E, 0x00, 0x1E, 0x10}},
    {0xB5, 12, 0, {0x1D, 0x1C, 0x1E, 0x0A, 0x15, 0x03, 0x11, 0x08, 0x1E, 0x01, 0x1E, 0x12}},
    {0xB6, 7, 0, {0x77, 0x77, 0x00, 0x0A, 0xFF, 0x0A, 0xFF}},
    {0x86, 14, 0, {0xCD, 0x04, 0xB1, 0x02, 0x58, 0x12, 0x58, 0x0C, 0x13, 0x01, 0xA5, 0x00, 0xA5, 0xA5}},
    {0xB7, 16, 0, {0x07, 0x0A, 0x0E, 0x06, 0x05, 0x03, 0x2B, 0x03, 0x03, 0x42, 0x07, 0x10, 0x10, 0x2E, 0x3F, 0x0D}},
    {0xB8, 16, 0, {0x07, 0x0A, 0x0D, 0x05, 0x05, 0x02, 0x2B, 0x02, 0x03, 0x42, 0x06, 0x10, 0x0F, 0x2E, 0x3F, 0x0D}},
    {0xB9, 2, 0, {0x23, 0x23}},
    {0xBF, 6, 0, {0x10, 0x14, 0x14, 0x0B, 0x0B, 0x0B}},
    {0xF2, 1, 0, {0x00}},
    {0x73, 5, 0, {0x04, 0xDA, 0x12, 0x54, 0x47}},
    {0x77, 5, 0, {0x6B, 0x5B, 0xFD, 0xC3, 0xC5}},
    {0x7A, 2, 0, {0x15, 0x27}},
    {0x7B, 2, 0, {0x04, 0x57}},
    {0x7E, 2, 0, {0x01, 0x0E}},
    {0xBF, 1, 0, {0x36}},
    {0xE3, 2, 0, {0x40, 0x40}},
    {0xF0, 1, 0, {0x00}},
    {0xD0, 1, 0, {0x00}},
    {0x2A, 4, 0, {0x00, 0x00, 0x01, 0x3F}},
    {0x2B, 4, 0, {0x00, 0x00, 0x01, 0xDF}},
    {0x21, 0, 0, {}},
    {0x11, 0, 120, {}},
    {0x29, 0, 0, {}},
    {0x2C, 0, 0, {}},
    {0x3A, 1, 0, {0x01}},
    {0x36, 1, 0, {0x00}},
    {0x35, 1, 20, {0x01}},
};

static bool IRAM_ATTR onColorDone(esp_lcd_panel_io_handle_t, esp_lcd_panel_io_event_data_t*, void*) {
  BaseType_t woken = pdFALSE;
  xSemaphoreGiveFromISR(s_done, &woken);
  return woken == pdTRUE;
}

bool St77922Qspi::begin() {
  pinMode(PIN_BACKLIGHT, OUTPUT);
  digitalWrite(PIN_BACKLIGHT, LOW);

  spi_bus_config_t bus = {};
  bus.sclk_io_num = PIN_SCLK;
  bus.data0_io_num = PIN_D0;
  bus.data1_io_num = PIN_D1;
  bus.data2_io_num = PIN_D2;
  bus.data3_io_num = PIN_D3;
  bus.data4_io_num = -1;
  bus.data5_io_num = -1;
  bus.data6_io_num = -1;
  bus.data7_io_num = -1;
  bus.max_transfer_sz = kChunkBytes + 16;
  bus.flags = SPICOMMON_BUSFLAG_MASTER | SPICOMMON_BUSFLAG_QUAD;
  if (spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO) != ESP_OK) return false;

  s_done = xSemaphoreCreateBinary();
  esp_lcd_panel_io_spi_config_t io = {};
  io.cs_gpio_num = PIN_CS;
  io.dc_gpio_num = -1;
  io.spi_mode = 0;
  io.pclk_hz = 40 * 1000 * 1000;
  io.trans_queue_depth = 4;
  io.on_color_trans_done = onColorDone;
  io.lcd_cmd_bits = 32;
  io.lcd_param_bits = 8;
  io.flags.quad_mode = 1;
  if (esp_lcd_new_panel_io_spi((esp_lcd_spi_bus_handle_t)SPI2_HOST, &io, &s_io) != ESP_OK) return false;

  for (auto& b : s_dma) {
    b = (uint16_t*)heap_caps_malloc(kChunkBytes, MALLOC_CAP_DMA | MALLOC_CAP_INTERNAL);
    if (!b) return false;
  }

  writeCommand(0x01, nullptr, 0);   // software reset (hardware reset = EN)
  delay(120);
  for (const auto& c : kInit) {
    writeCommand(c.cmd, c.data, c.len);
    if (c.delayMs) delay(c.delayMs);
  }
  return true;
}

void St77922Qspi::setBacklight(bool on) { digitalWrite(PIN_BACKLIGHT, on ? HIGH : LOW); }

void St77922Qspi::writeCommand(uint8_t cmd, const uint8_t* data, size_t len) {
  esp_lcd_panel_io_tx_param(s_io, (int)((OPCODE_WRITE_CMD << 24) | ((uint32_t)cmd << 8)), data, len);
}

void St77922Qspi::writePixels(int y0, int rows, const uint16_t* src) {
  const uint8_t caset[] = {0, 0, (uint8_t)((kWidth - 1) >> 8), (uint8_t)((kWidth - 1) & 0xFF)};
  const int y1 = y0 + rows - 1;
  const uint8_t raset[] = {(uint8_t)(y0 >> 8), (uint8_t)y0, (uint8_t)(y1 >> 8), (uint8_t)y1};
  writeCommand(0x2A, caset, 4);
  writeCommand(0x2B, raset, 4);
  esp_lcd_panel_io_tx_color(s_io, (int)((OPCODE_WRITE_COLOR << 24) | (0x2C << 8)), src, (size_t)kWidth * rows * 2);
}

void St77922Qspi::pushFrame(const uint16_t* pixels) {
  int buf = 0;
  bool inFlight = false;
  for (int y = 0; y < kHeight; y += kChunkRows) {
    const int rows = min(kChunkRows, kHeight - y);
    const uint16_t* src = pixels + (size_t)y * kWidth;
    uint16_t* dst = s_dma[buf];
    for (int i = 0; i < kWidth * rows; i++) dst[i] = (uint16_t)((src[i] >> 8) | (src[i] << 8));   // panel wants MSB first
    if (inFlight) xSemaphoreTake(s_done, portMAX_DELAY);  // previous chunk done -> its buffer is free again
    writePixels(y, rows, dst);
    inFlight = true;
    buf ^= 1;
  }
  if (inFlight) xSemaphoreTake(s_done, portMAX_DELAY);
}
